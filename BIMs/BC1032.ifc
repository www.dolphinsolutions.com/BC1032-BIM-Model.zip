Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
Time: 2019-06-28T12:37:15
Written by: The EXPRESS Data Manager Version 5.01.0100.02.64mod : 6 Jun 2012
Made in: 20140709_2115(x64) - Exporter 2014.0.2014.0709 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.01.0100.02.64mod : 6 Jun 2012 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Fri Jun 28 12:37:15 2019 * Host: BIM-HP * Database: C:\Users\dcole\AppData\Local\Temp\{EF90F35E-83DE-4007-B4C5-CDD5CD62EED3}\ifc * Database version: 5507 * Database creation date: Fri Jun 28 12:37:14 2019 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Fri Jun 28 12:37:15 2019 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Fri Jun 28 12:37:15 2019 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject
LongName: P:\Fastrack\53721_DOLPHIN SOLUTIONS LIMITED\ADDITIONAL DRAWINGS 2019 BIM\06$JUNE\BC1022 -1032\BC1032.ifc

# IfcSite, Default
RefLatitude: 42, 24, 53, 508911; RefLongitude: -71, -15, -29, -58837; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Constraints - Elevation Base: Project Base Point; Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Structural: no; Building Story: yes; Name: Level 1
Graphics - Color: 0; Line Pattern: -3000010; Symbol at End 2 Default: yes; Line Weight: 1; Symbol at End 1 Default: no

# IfcBuildingElementProxy: BC1022 Dolphin Wall Mounted Soap Dispenser, BC1032:BC1022 Dolphin Wall Mounted Soap Dispenser:26475
In: Level 1
Material: Soap Pump
Phasing - Phase Created: New Construction
Constraints - Offset: 0 mm; Host: Level : Level 1; Moves With Nearby Elements: no; Level: Level: Level 1
Dimensions - Volume: 0.0000604046 m3; Maximum Panel Thickness: 55mm; Width: Body = Ø22.5mm Rosette = Ø44mm; Projection: 120mm; Panel Hole Diameter: Ø19mm; Recommended Minimum Distance: Behind soap unit = 108mm to allow for connections to soap feeds.
Pset_ManufacturerTypeInformation - Manufacturer: Dolphin Solutions Limited
Pset_BuildingElementProxyCommon - Reference: BC1022 Dolphin Wall Mounted Soap Dispenser
Identity Data - Assembly Code: D2090900; Address: Southpoint, Compass Park, Bodiam, Robertbridge, TN32 5BS; Manufacturer: Dolphin Solutions Limited; Assembly Description: Misc. Other Plumbing Systems; Email: info@dolphinsolutions.co.uk; Tel No.: +44 (0) 1424 202224; URL: www.dolphinsolutions.co.uk; Description: Wall mounted soap dispenser; Fax No.: +44 (0) 1424 205200; Model: BC1022
General - Product Data: Superior quality and timeless design for prestigious washrooms. Designed for heavy traffic prestigious environments. Solid brass construction with brushed satin plating. Soap feeds via a flexible tube (various lengths to order up to a maximum recommended length of 2m) to a container of your choice (ordered separately). Supplied with 2m of flexible feed tube Where several dispensers are installed together our multi-feed system is recommended: BC1900MA and BC1900MB. Can be installed into panels up to 55mm thick - hole diameter through panel 19mm. Can be used with Standard Liquid Hand Soap and Anti Bacterial Soap. Suitable for pressurised soap systems (including gravity fed).; Product Page Link: http://www.dolphinsolutions.co.uk/en/product/
